# Keil uVision project PatrolRobot.uvprojx, settings and files
target PatrolRobot (6240000::V6.24::ARMCLANG)
  device: STM32G474VETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: PatrolRobot +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32G474xx
  c include: ../Core/Inc;../Application/PatrolRobot;../Config;../BSP/GY906;../BSP/Bluetooth;../BSP/Ultrasonic;../BSP/ESP01S;../Middleware/MQTT;../BSP/K230;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: stm32g474xx_flash.sct
  group Application/MDK-ARM
    ./: startup_stm32g474xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c i2c.c tim.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Application/PatrolRobot
    ../Application/PatrolRobot/: patrol_robot_app.c telemetry.c vision_alert.c bluetooth_command.c
  group Config
    ../Config/: patrol_robot_config.h network_config.h mqtt_secret.h
  group BSP/GY906
    ../BSP/GY906/: gy906.c
  group BSP/Bluetooth
    ../BSP/Bluetooth/: bluetooth.c
  group BSP/Ultrasonic
    ../BSP/Ultrasonic/: ultrasonic.c
  group BSP/ESP01S
    ../BSP/ESP01S/: esp01s.c esp01s_at.c esp01s_tcp.c
  group Middleware/MQTT
    ../Middleware/MQTT/: mqtt_client.c mqtt_codec.c
  group BSP/K230
    ../BSP/K230/: k230.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_i2c.c stm32g4xx_hal_i2c_ex.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
software components: CMSIS:CORE 6.2.0
